# Keil uVision project MultiFunBagingMachine.uvprojx, settings and files
target MultiFunBagingMachine (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MultiFunBagingMachine +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Source\App\PLC;.\Source\App\LCD;.\Source\App;.\Source\CMSIS\Core\CM3\startup\arm;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\STM32F10x_StdPeriph_Driver\src;.\Source\uCGUI\inc;.\Source\uCGUI\LCDDriver;.\Source\uCGUI\Config;.\Source\App\SMEC98SP\Header
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./Source/App/: fsmc_sram.c stm32f10x_it.c main.c DataCalc.c
  group PLC
    ./Source/App/: PIPE.c flashbase.c flashspace.c
    ./Source/App/PLC/: Beeper.c RealTimer.c MainWork.c CtrlLever.c VSPIDAC.c IOManage.c USART1.c Modbus.c PlusIn.c PlusOut.c Curve.c CPArray.c CRC.C ADC.c USART2.c USART4.C USART3.c DACCtrl.c
  group CMSIS
    ./Source/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group lib
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SMEC98SP
    ./Source/App/SMEC98SP/Source/: des.c iic_smec98sp.c sha1.c smec98sp.c smec98spManage.c
